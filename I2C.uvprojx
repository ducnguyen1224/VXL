# Keil uVision project I2C.uvprojx, settings and files
target GPIO (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: lcd +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c include: .\project;.\lib\CMSIS\CM3\CoreSupport;.\lib\STM32F10x_StdPeriph_Driver\inc;.\lib\CMSIS\CM3\DeviceSupport\ST\STM32F10x\startup\arm;.\my_lib
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group lib
    ./lib/CMSIS/CM3/CoreSupport/: core_cm3.c
    ./lib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
    ./lib/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_i2c.c
    ./my_lib/: i2c_lcd.c keypad.c
  group user
    ./project/: main.c stm32f10x_it.c system_stm32f10x.c
